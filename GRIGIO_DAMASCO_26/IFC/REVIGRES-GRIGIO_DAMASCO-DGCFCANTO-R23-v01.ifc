Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 05573a8d-cc8a-41ac-a022-633e54c98c3a, NumberOfSaves: 2], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [Architecture]
Time: 2026-06-12T14:50:45+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (ENU) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1

# IfcCovering: REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-R23-v01:REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-29.5x59.2-MATTRECT, REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-R23-v01:REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-29.5x59.2-MATTRECT:10690
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - IsExternal: no; Finish: REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-29.5x59.2-MATTRECT
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-29.5x59.2-MATTRECT
Pset_CoveringCommon - Reference: REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-29.5x59.2-MATTRECT
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-29.5x59.2-MATTRECT
IFC.REVIGRES-Dados gerais-Generic Model - Nome: REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-29.5x59.2-MATT_RECT; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Generic Model - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Grigio Damasco; PesoLiquido: 0; Acabamento: MATT_RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/grigio-damasco; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm
IFC.REVIGRES-Dados de especificação-Generic Model - EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Generic Model - AlturaNominal: 8.5 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Generic Model - ItemEParcialmenteReciclado: 0.08; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaElectricaExportada: 1.55; EnergiaTermicaExportada: 0; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²; PotencialDeAquecimentoGlobalTotal: 0

# IfcCovering: REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-R23-v01:REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-29.5x59.2-POL, REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-R23-v01:REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-29.5x59.2-POL:10695
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - IsExternal: no; Finish: REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-29.5x59.2-POL
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-29.5x59.2-POL
Pset_CoveringCommon - Reference: REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-29.5x59.2-POL
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-29.5x59.2-POL
IFC.REVIGRES-Dados gerais-Generic Model - Nome: REVIGRES-GRIGIO_DAMASCO-DGCFCANTO-29.5x59.2-POL; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Grigio Damasco; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/grigio-damasco; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm
IFC.REVIGRES-Dados de especificação-Generic Model - EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Generic Model - AlturaNominal: 8 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Generic Model - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; PotencialDeAquecimentoGlobalTotal: 0; ItemEParcialmenteReciclado: 0.08; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
