Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: a50ad512-7c8a-4044-a6f5-9528115d842c, NumberOfSaves: 231], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [Architecture]
Time: 2026-06-12T14:53:13+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (ENU) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1

# IfcCovering: Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-8x118.6-MATT_RECT, Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-8x118.6-MATT_RECT:181427
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-GRIGIO_DAMASCO-RB-8x118.6-MATT_RECT
Pset_CoveringCommon - Reference: REVIGRES-GRIGIO_DAMASCO-RB-8x118.6-MATT_RECT
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-GRIGIO_DAMASCO-RB-8x118.6-MATT_RECT
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-GRIGIO_DAMASCO-RB-8x118.6-MATT_RECT
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - Type: REVIGRES-GRIGIO_DAMASCO-RB-8x118.6-MATT_RECT; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Grigio Damasco; Acabamento: MATT_RECT; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/grigio-damasco; PaisOrigem: Portugal
IFC.REVIGRES-Dados de especificação-Wall Sweeps - EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 9.8 mm; ComprimentoNominal: 8 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; EnergiaTermicaExportada: 0; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-8x118.6-POL, Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-8x118.6-POL:181432
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-GRIGIO_DAMASCO-RB-8x118.6-POL
Pset_CoveringCommon - Reference: REVIGRES-GRIGIO_DAMASCO-RB-8x118.6-POL
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-GRIGIO_DAMASCO-RB-8x118.6-POL
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-GRIGIO_DAMASCO-RB-8x118.6-POL
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - Type: REVIGRES-GRIGIO_DAMASCO-RB-8x118.6-POL; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Grigio Damasco; Acabamento: POL; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/grigio-damasco; PaisOrigem: Portugal
IFC.REVIGRES-Dados de especificação-Wall Sweeps - EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 9.3 mm; ComprimentoNominal: 8 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-8x44.35-MATT_RECT, Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-8x44.35-MATT_RECT:181433
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-GRIGIO_DAMASCO-RB-8x44.35-MATT_RECT
Pset_CoveringCommon - Reference: REVIGRES-GRIGIO_DAMASCO-RB-8x44.35-MATT_RECT
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-GRIGIO_DAMASCO-RB-8x44.35-MATT_RECT
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-GRIGIO_DAMASCO-RB-8x44.35-MATT_RECT
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - Type: REVIGRES-GRIGIO_DAMASCO-RB-8x44.35-MATT_RECT; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Grigio Damasco; Acabamento: MATT_RECT; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/grigio-damasco; PaisOrigem: Portugal
IFC.REVIGRES-Dados de especificação-Wall Sweeps - EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 8.2 mm; ComprimentoNominal: 8 mm; LarguraNominal: 45 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-8x44.35-POL, Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-8x44.35-POL:181437
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-GRIGIO_DAMASCO-RB-8x44.35-POL
Pset_CoveringCommon - Reference: REVIGRES-GRIGIO_DAMASCO-RB-8x44.35-POL
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-GRIGIO_DAMASCO-RB-8x44.35-POL
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-GRIGIO_DAMASCO-RB-8x44.35-POL
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - Type: REVIGRES-GRIGIO_DAMASCO-RB-8x44.35-POL; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Grigio Damasco; Acabamento: POL; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/grigio-damasco; PaisOrigem: Portugal
IFC.REVIGRES-Dados de especificação-Wall Sweeps - EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 7.7 mm; ComprimentoNominal: 8 mm; LarguraNominal: 45 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-8x59.2-MATT_RECT, Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-8x59.2-MATT_RECT:181430
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-GRIGIO_DAMASCO-RB-8x59.2-MATT_RECT
Pset_CoveringCommon - Reference: REVIGRES-GRIGIO_DAMASCO-RB-8x59.2-MATT_RECT
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-GRIGIO_DAMASCO-RB-8x59.2-MATT_RECT
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-GRIGIO_DAMASCO-RB-8x59.2-MATT_RECT
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - Type: REVIGRES-GRIGIO_DAMASCO-RB-8x59.2-MATT_RECT; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Grigio Damasco; Acabamento: MATT_RECT; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/grigio-damasco; PaisOrigem: Portugal
IFC.REVIGRES-Dados de especificação-Wall Sweeps - EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 8.5 mm; ComprimentoNominal: 8 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-8x59.2-POL, Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-8x59.2-POL:181429
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-GRIGIO_DAMASCO-RB-8x59.2-POL
Pset_CoveringCommon - Reference: REVIGRES-GRIGIO_DAMASCO-RB-8x59.2-POL
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-GRIGIO_DAMASCO-RB-8x59.2-POL
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-GRIGIO_DAMASCO-RB-8x59.2-POL
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - Type: REVIGRES-GRIGIO_DAMASCO-RB-8x59.2-POL; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Grigio Damasco; Acabamento: POL; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/grigio-damasco; PaisOrigem: Portugal
IFC.REVIGRES-Dados de especificação-Wall Sweeps - EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 8 mm; ComprimentoNominal: 8 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-8x88.9-MATT_RECT, Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-8x88.9-MATT_RECT:181436
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-GRIGIO_DAMASCO-RB-8x88.9-MATT_RECT
Pset_CoveringCommon - Reference: REVIGRES-GRIGIO_DAMASCO-RB-8x88.9-MATT_RECT
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-GRIGIO_DAMASCO-RB-8x88.9-MATT_RECT
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-GRIGIO_DAMASCO-RB-8x88.9-MATT_RECT
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - Type: REVIGRES-GRIGIO_DAMASCO-RB-8x88.9-MATT_RECT; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Grigio Damasco; Acabamento: MATT_RECT; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/grigio-damasco; PaisOrigem: Portugal
IFC.REVIGRES-Dados de especificação-Wall Sweeps - EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 10.5 mm; ComprimentoNominal: 8 mm; LarguraNominal: 90 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-8x88.9-POL, Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-8x88.9-POL:181434
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-GRIGIO_DAMASCO-RB-8x88.9-POL
Pset_CoveringCommon - Reference: REVIGRES-GRIGIO_DAMASCO-RB-8x88.9-POL
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-GRIGIO_DAMASCO-RB-8x88.9-POL
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-GRIGIO_DAMASCO-RB-8x88.9-POL
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - Type: REVIGRES-GRIGIO_DAMASCO-RB-8x88.9-POL; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Grigio Damasco; Acabamento: POL; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/grigio-damasco; PaisOrigem: Portugal
IFC.REVIGRES-Dados de especificação-Wall Sweeps - EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 9.8 mm; ComprimentoNominal: 8 mm; LarguraNominal: 90 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-9.5x29.5-MATTRECT, Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-9.5x29.5-MATTRECT:181435
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-GRIGIO_DAMASCO-RB-9.5x29.5-MATTRECT
Pset_CoveringCommon - Reference: REVIGRES-GRIGIO_DAMASCO-RB-9.5x29.5-MATTRECT
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-GRIGIO_DAMASCO-RB-9.5x29.5-MATTRECT
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-GRIGIO_DAMASCO-RB-9.5x29.5-MATT_RECT
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - Type: REVIGRES-GRIGIO_DAMASCO-RB-9.5x29.5-MATTRECT; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Grigio Damasco; Acabamento: MATT_RECT; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/grigio-damasco; PaisOrigem: Portugal
IFC.REVIGRES-Dados de especificação-Wall Sweeps - EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 8.5 mm; ComprimentoNominal: 9.5 mm; LarguraNominal: 30 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-9.5x29.5-POL, Wall Sweep:REVIGRES-GRIGIO_DAMASCO-RB-9.5x29.5-POL:181431
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-GRIGIO_DAMASCO-RB-9.5x29.5-POL
Pset_CoveringCommon - Reference: REVIGRES-GRIGIO_DAMASCO-RB-9.5x29.5-POL
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-GRIGIO_DAMASCO-RB-9.5x29.5-POL
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-GRIGIO_DAMASCO-RB-9.5x29.5-POL
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - Type: REVIGRES-GRIGIO_DAMASCO-RB-9.5x29.5-POL; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Grigio Damasco; Acabamento: POL; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/grigio-damasco; PaisOrigem: Portugal
IFC.REVIGRES-Dados de especificação-Wall Sweeps - EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 8 mm; ComprimentoNominal: 9.5 mm; LarguraNominal: 30 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
